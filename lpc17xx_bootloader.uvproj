# Keil uVision project lpc17xx_bootloader.uvproj, settings and files
target LPC1768 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lpc17xx_bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: MAX_URI_LENGTH=512,__LPC17XX__,USB_DEVICE_ONLY,APPBAUD=100000
  c misc: --gnu
  c include: CMSISv2p00_LPC17xx\inc;CMSISv2p00_LPC17xx\src;LPC17xxLib\inc;fatfs;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ./CMSISv2p00_LPC17xx/src/: core_cm3.c system_LPC17xx.c startup_LPC17xx.s
  group LPCLIB
    ./LPC17xxLib/src/: lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_debug_frmwrk.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group fatfs
    ./fatfs/: diskio.c ff.c
    ./fatfs/option/: ccsbcs.c syscall.c unicode.c
  group bootloader
    ./: baudfinder.c dfu.c gpio.c lpc17xx_usb.c main.c sbl_iap.c SDCard.c spi.c uart.c usbcore.c usbhw.c spi_lcd.c
target LPC1768-Release (ARM-ADS)
  device: LPC1768 NXP
  cpu: as above
  output: lpc17xx_bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
